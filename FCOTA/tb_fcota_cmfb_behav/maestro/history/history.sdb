<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.0
			<timestamp>Jul 29 20:53:33 2024</timestamp>
			<uuid>{3b5732a1-9aa0-481a-b044-1d0ef9813e2f}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/vlsi/cadence/FCOTA/tb_fcota_cmfb_behav/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/vlsi/cadence/FCOTA/tb_fcota_cmfb_behav/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/vlsi/simulation/results/maestro/Interactive.0</psfdir>
			<simdir>/home/vlsi/simulation/results/maestro/Interactive.0</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.1
			<timestamp>Jul 29 22:45:29 2024</timestamp>
			<uuid>{1e2be70a-5950-40e3-8af9-f542de43bf75}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/vlsi/cadence/FCOTA/tb_fcota_cmfb_behav/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/vlsi/cadence/FCOTA/tb_fcota_cmfb_behav/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/vlsi/simulation/results/maestro/Interactive.1</psfdir>
			<simdir>/home/vlsi/simulation/results/maestro/Interactive.1</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.2
			<timestamp>Jul 29 22:51:57 2024</timestamp>
			<uuid>{4ffff24e-43e7-4950-a3e6-7ecd2f52eb3d}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/vlsi/cadence/FCOTA/tb_fcota_cmfb_behav/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/vlsi/cadence/FCOTA/tb_fcota_cmfb_behav/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/vlsi/simulation/results/maestro/Interactive.2</psfdir>
			<simdir>/home/vlsi/simulation/results/maestro/Interactive.2</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Aug 13 19:38:02 2024</timestamp>
			<uuid>{082d284c-7867-417f-87b6-a6ae7aecf631}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/vlsi/cadence/FCOTA/tb_fcota_cmfb_behav/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/vlsi/cadence/FCOTA/tb_fcota_cmfb_behav/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/vlsi/simulation/results/maestro/ExplorerRun.0</psfdir>
			<simdir>/home/vlsi/simulation/results/maestro/ExplorerRun.0</simdir>
		</historyentry>
	</history>
</setupdb>
